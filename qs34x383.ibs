| I/O Buffer Information Specification (IBIS) Version 3.2 (August 20, 1999)
| IBIS is a standard for electronic behavioral specifications of integrated
| circuit input/output analog characteristics.
[IBIS Ver]   3.2
[File Name]   qs34x383.ibs
[File Rev]   1.0
[Date]   October 27, 1999
[Notes]   IDT provides IBIS models as a service to our customers. You
   and your company shall not distribute, convey, sell or give
   these models to anyone else without receiving prior written
   permission from IDT. IDT reserves the right to make changes to
   its products or to discontinue any semiconductor product or
   service without notice, and advises its customers to obtain
   the latest version of relevant information to verify, before
   placing orders, that the information being relied on is
   current. Please be aware that your receipt and subsequent use
   of the IBIS information provided shall serve as acceptance of
   the terms and conditions of this agreement. If you do not
   accept these terms, you should return the IBIS model and any
   other accompanying information immediately.
[Disclaimer]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
[Copyright]   (C) Copyright 1999 Integrated Device Technology, Inc. All
   rights reserved. Unauthorized reproduction and/or distribution
   is strictly prohibited.
|   Component QS34X383
[Component]   QS34X383
[Manufacturer]   Integrated Device Technology, Inc.
[Package]
| Package parasitics.  Uncomment one set.
| variable   typ   min   max
| SOIC
R_pkg   0.01   0.01   0.01
L_pkg   4.00nH   4.00nH   4.00nH
C_pkg   0.70pF   0.70pF   0.70pF
[Pin]   signal_name   model_name   R_pin   L_pin   C_pin
|1   BEAB   ENABLE   NA   NA   NA
2   C0   NC   NA   NA   NA
3   A0   NC   NA   NA   NA
4   B0   NC   NA   NA   NA
5   D0   NC   NA   NA   NA
6   C1   NC   NA   NA   NA
7   A1   NC   NA   NA   NA
8   B1   NC   NA   NA   NA
9   D1   NC   NA   NA   NA
10   GND   GND   NA   NA   NA
|11   BEBB   ENABLE   NA   NA   NA
12   C4   NC   NA   NA   NA
13   A4   NC   NA   NA   NA
14   B4   NC   NA   NA   NA
15   D4   NC   NA   NA   NA
16   C5   NC   NA   NA   NA
17   A5   NC   NA   NA   NA
18   B5   NC   NA   NA   NA
19   D5   NC   NA   NA   NA
20   GND   GND   NA   NA   NA
|21   BECB   ENABLE   NA   NA   NA
22   C8   NC   NA   NA   NA
23   A8   NC   NA   NA   NA
24   B8   NC   NA   NA   NA
25   D8   NC   NA   NA   NA
26   C9   NC   NA   NA   NA
27   A9   NC   NA   NA   NA
28   B9   NC   NA   NA   NA
29   D9   NC   NA   NA   NA
30   GND   GND   NA   NA   NA
|31   BEDB   ENABLE   NA   NA   NA
32   C12   NC   NA   NA   NA
33   A12   NC   NA   NA   NA
34   B12   NC   NA   NA   NA
35   D12   NC   NA   NA   NA
36   C13   NC   NA   NA   NA
37   A13   NC   NA   NA   NA
38   B13   NC   NA   NA   NA
39   D13   NC   NA   NA   NA
40   GND   GND   NA   NA   NA
|41   BXD   ENABLE   NA   NA   NA
42   C14   NC   NA   NA   NA
43   A14   NC   NA   NA   NA
44   B14   NC   NA   NA   NA
45   D14   NC   NA   NA   NA
46   C15   NC   NA   NA   NA
47   A15   NC   NA   NA   NA
48   B15   NC   NA   NA   NA
49   D15   NC   NA   NA   NA
50   VCC   POWER   NA   NA   NA
|51   BXC   ENABLE   NA   NA   NA
52   C10   NC   NA   NA   NA
53   A10   NC   NA   NA   NA
54   B10   NC   NA   NA   NA
55   D10   NC   NA   NA   NA
56   C11   NC   NA   NA   NA
57   A11   NC   NA   NA   NA
58   B11   NC   NA   NA   NA
59   D11   NC   NA   NA   NA
60   VCC   POWER   NA   NA   NA
|61   BXB   ENABLE   NA   NA   NA
62   C6   NC   NA   NA   NA
63   A6   NC   NA   NA   NA
64   B6   NC   NA   NA   NA
65   D6   NC   NA   NA   NA
66   C7   NC   NA   NA   NA
67   A7   NC   NA   NA   NA
68   B7   NC   NA   NA   NA
69   D7   NC   NA   NA   NA
70   VCC   POWER   NA   NA   NA
|71   BXA   ENABLE   NA   NA   NA
72   C2   NC   NA   NA   NA
73   A2   NC   NA   NA   NA
74   B2   NC   NA   NA   NA
75   D2   NC   NA   NA   NA
76   C3   NC   NA   NA   NA
77   A3   NC   NA   NA   NA
78   B3   NC   NA   NA   NA
79   D3   NC   NA   NA   NA
80   VCC   POWER   NA   NA   NA
[Series Pin Mapping]   pin_2   model_name   function_table_group
2   3   QSIO   1
5   3   QSIO   1
2   4   QSIO   1
5   4   QSIO   1
6   7   QSIO   2
9   7   QSIO   2
6   8   QSIO   2
9   8   QSIO   2
12   13   QSIO   3
15   13   QSIO   3
12   14   QSIO   3
15   14   QSIO   3
16   17   QSIO   4
19   17   QSIO   4
16   18   QSIO   4
19   18   QSIO   4
22   23   QSIO   5
25   23   QSIO   5
22   24   QSIO   5
25   24   QSIO   5
26   27   QSIO   6
29   27   QSIO   6
26   28   QSIO   6
29   28   QSIO   6
32   33   QSIO   7
35   33   QSIO   7
32   34   QSIO   7
35   34   QSIO   7
36   37   QSIO   8
39   37   QSIO   8
36   38   QSIO   8
39   38   QSIO   8
42   43   QSIO   9
45   43   QSIO   9
42   44   QSIO   9
45   44   QSIO   9
46   47   QSIO   10
49   47   QSIO   10
46   48   QSIO   10
49   48   QSIO   10
52   53   QSIO   11
55   53   QSIO   11
52   54   QSIO   11
55   54   QSIO   11
56   57   QSIO   12
59   57   QSIO   12
56   58   QSIO   12
59   58   QSIO   12
62   63   QSIO   13
65   63   QSIO   13
62   64   QSIO   13
65   64   QSIO   13
66   67   QSIO   14
69   67   QSIO   14
66   68   QSIO   14
69   68   QSIO   14
72   73   QSIO   15
75   73   QSIO   15
72   74   QSIO   15
75   74   QSIO   15
76   77   QSIO   16
79   77   QSIO   16
76   78   QSIO   16
79   78   QSIO   16
|   Series_MOSFET   This model type is for series switch
|   devices that can described by [On], [Off],
|   [R Series], [L Series], [Rl Series],
|   [C Series], [Lc Series], [Rc Series],
|   [Series Current] and [Series MOSFET]
|   keywords
[Model]   QSIO
Model_type   Series_switch
| variable   typ   min   max
| Silicon die-compacitance (excluding package cap)
C_comp   8.24pF   NA   NA
[Temperature Range]   25.0   85   -40
[Voltage Range]   5.0V   4.75V   5.25V
[On]
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[Off]
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| Models and submodels in the file (1): QSIO (Series_switch)
